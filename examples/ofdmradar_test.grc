options:
  parameters:
    author: david
    generate_options: qt_gui
    id: ofdmradar_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: radar_params
  id: ofdmradar_ofdmradar_params
  parameters:
    carriers: '1024'
    constellation_order: '4'
    custom_constellation: '[1.0, -1.0]'
    cyclic_prefix_length: '128'
    dc_guard: '1'
    modulation_scheme: BPSK
    nyquist_guard: '64'
    seed: '0'
    symbols: '64'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 250e6
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '0.05'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '20'
    freq: '10'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '5'
    freq: '10'
    offset: '10'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1e-3'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '5e-5'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '1048576'
    type: complex
  states: {}
- name: channels_channel_model2_0
  id: channels_channel_model2
  parameters:
    epsilon: '25'
    noise_voltage: '0'
    seed: '0'
    taps: 1.0 + 1.0j
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '30'
    decim: '1'
    samp_rate: samp_rate
    taps: '[0]*50 + [0.3] + [0]*30 + [0.1] + [0]*10'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-200'
    decim: '1'
    samp_rate: samp_rate
    taps: '[0]*99 + [0.1] + [0]*10 + [0.4] + [0]*10'
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: ofdmradar_ofdmradar_gui_0
  id: ofdmradar_ofdmradar_gui
  parameters:
    gui_hint: 0, 1, 2, 1
    ofdm_params: radar_params
  states: {}
- name: ofdmradar_ofdmradar_rx_0
  id: ofdmradar_ofdmradar_rx
  parameters:
    buffer_size: radar_params.frame_length
    len_tag_key: packet_len
    ofdm_radar_params: radar_params
  states: {}
- name: ofdmradar_ofdmradar_tx_0
  id: ofdmradar_ofdmradar_tx
  parameters:
    len_tag_key: packet_len
    ofdm_radar_params: radar_params
  states: {}
- name: ofdmrx_mod
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph

      import numpy as np
      import matplotlib
      import matplotlib.pyplot as plt

      counter = 0
      running_sum = np.zeros((1024, 64), dtype=float)

      def handle_data(data):
          global counter,running_sum
          return
          estimate = np.fft.fftshift(data, axes=[0])
          estimate = np.transpose(estimate)

          matplotlib.use("agg")
          plt.figure(figsize=(8, 10))
          running_sum += np.abs(estimate)[::-1,:]
          plt.imshow(running_sum, interpolation="none", aspect=1/2, extent=[-32, 31, 0, 1023])
          # plt.imshow(np.transpose(np.abs(data)))
          # plt.colorbar()
          plt.ylim([0, 200])
          plt.ylabel("Distance")
          plt.xlabel("Doppler");
          ofile = f"/tmp/periodograms/{counter:03}.png"

          plt.savefig(ofile)
          plt.close()
          counter += 1
          # print(f"Wrote: {ofile}")
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    gui_hint: 1, 0, 1, 1
    type: complex
    update_time: 1/30
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    gui_hint: 0, 0, 1, 1
    type: complex
    update_time: 1/30
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '4096'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
    update_time: 1/10
  states: {state: disabled}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '2']
- [analog_sig_source_x_0, '0', channels_channel_model2_0, '1']
- [analog_sig_source_x_0_0, '0', channels_channel_model2_0, '2']
- [blocks_add_xx_0, '0', ofdmradar_ofdmradar_rx_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', ofdmradar_ofdmradar_gui_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_add_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', blocks_add_xx_0, '1']
- [ofdmradar_ofdmradar_rx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [ofdmradar_ofdmradar_tx_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
