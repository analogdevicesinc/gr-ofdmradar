options:
  parameters:
    author: david
    generate_options: qt_gui
    id: ofdmradar_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: radar_params
  id: ofdmradar_ofdmradar_params
  parameters:
    carriers: '1024'
    constellation_order: '4'
    custom_constellation: '[1.0, -1.0]'
    cyclic_prefix_length: '128'
    dc_guard: '1'
    modulation_scheme: BPSK
    nyquist_guard: '64'
    peri_carriers: '4096'
    peri_symbols: '1024'
    seed: '0'
    symbols: '128'
    wintype: HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 250e6
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '0.1'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1e-3'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: complex
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '1048576'
    type: complex
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '30000'
    decim: '1'
    samp_rate: samp_rate
    taps: '[0]*50 + [0.3] + [0]*30 + [0.1] + [0]*10'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '10'
    decim: '1'
    samp_rate: samp_rate
    taps: '[0]*99 + [0.1] + [0]*10 + [0.4] + [0]*10'
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: ofdmradar_ofdmradar_gui_0
  id: ofdmradar_ofdmradar_gui
  parameters:
    gui_hint: 0, 1, 2, 1
    ofdm_params: radar_params
  states: {}
- name: ofdmradar_ofdmradar_rx_0
  id: ofdmradar_ofdmradar_rx
  parameters:
    buffer_size: radar_params.frame_length
    len_tag_key: packet_len
    ofdm_radar_params: radar_params
  states: {}
- name: ofdmradar_ofdmradar_tx_0
  id: ofdmradar_ofdmradar_tx
  parameters:
    len_tag_key: packet_len
    ofdm_radar_params: radar_params
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    gui_hint: 1, 0, 1, 1
    type: complex
    update_time: 1/30
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    gui_hint: 0, 0, 1, 1
    type: complex
    update_time: 1/30
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '4096'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
    update_time: 1/10
  states: {state: disabled}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '2']
- [blocks_add_xx_0, '0', ofdmradar_ofdmradar_rx_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_probe_rate_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', ofdmradar_ofdmradar_gui_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_add_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', blocks_add_xx_0, '1']
- [ofdmradar_ofdmradar_rx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [ofdmradar_ofdmradar_tx_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
