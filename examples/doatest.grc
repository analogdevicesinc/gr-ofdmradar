options:
  parameters:
    author: david
    generate_options: qt_gui
    id: doatest
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: SNR
  id: variable
  parameters:
    value: '0'
  states: {}
- name: alpha
  id: variable
  parameters:
    value: '50'
  states: {}
- name: array_size
  id: variable
  parameters:
    value: '4'
  states: {}
- name: output_resolution
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samples
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: targets
  id: variable
  parameters:
    value: '1'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
    vlen: array_size
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: test_waveform_gen.get_waveform(array_size, samples * 8, alpha / 180 * np.pi, SNR)
    vlen: array_size
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: array_size
    type: complex
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: ofdmradar_array_corr_0
  id: ofdmradar_array_corr
  parameters:
    array_size: array_size
    samples: samples
  states: {}
- name: ofdmradar_array_music_0
  id: ofdmradar_array_music
  parameters:
    array_size: array_size
    output_resolution: output_resolution
    targets: targets
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    color4: '"cyan"'
    nconnections: '4'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: output_resolution
    x_start: '-90'
    x_step: 180 / output_resolution
    ymax: '1.1'
    ymin: '0'
  states: {}
- name: test_waveform_gen
  id: epy_module
  parameters:
    source_code: |
      import numpy as np

      def get_waveform(elements, N, alpha, SNR_dB):
          s = np.ones((elements, N)) # np.exp(1j * 0.1 * 2*np.pi * np.arange(elements))
          SNR = 10 ** (SNR_dB/10)
          N_0 = 1/SNR
          sigma = np.sqrt(N_0/2)
          n = sigma * (np.random.randn(elements, N) + 1j * np.random.randn(elements, N))
          x = n + s
          omega = np.sin(alpha)
          d = np.arange(elements, dtype=float)/2
          steer = np.exp(1j * 2*np.pi * omega * d)
          x = np.tile((x * steer[:,np.newaxis]), 2)
          x = np.transpose(x).reshape(np.prod(x.shape))
          return x
  states: {}

connections:
- [blocks_throttle_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_throttle_0, '0', ofdmradar_array_corr_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_vector_to_streams_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_vector_to_streams_0, '1', qtgui_const_sink_x_0, '1']
- [blocks_vector_to_streams_0, '2', qtgui_const_sink_x_0, '2']
- [blocks_vector_to_streams_0, '3', qtgui_const_sink_x_0, '3']
- [ofdmradar_array_corr_0, '0', ofdmradar_array_music_0, '0']
- [ofdmradar_array_music_0, '0', qtgui_vector_sink_f_0, '0']

metadata:
  file_format: 1
