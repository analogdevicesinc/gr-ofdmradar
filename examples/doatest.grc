options:
  parameters:
    author: david
    generate_options: qt_gui
    id: doatest
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: SNR
  id: variable
  parameters:
    value: '0'
  states: {}
- name: alpha
  id: variable
  parameters:
    value: '0'
  states: {state: disabled}
- name: alpha
  id: variable_qtgui_range
  parameters:
    start: '-90'
    step: '1'
    stop: '90'
    value: '0'
  states: {}
- name: array_size
  id: variable
  parameters:
    value: '4'
  states: {}
- name: output_resolution
  id: variable
  parameters:
    value: '180'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: samples
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: targets
  id: variable
  parameters:
    value: '1'
  states: {}
- name: array_calib_button
  id: variable_qtgui_msg_push_button
  parameters:
    label: Calibrate Array
    msgName: pressed
    type: bool
    value: 'True'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: 180 / np.pi
    type: float
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
    vlen: array_size
  states: {state: disabled}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: array_size
    type: complex
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: test_waveform_gen.get_waveform(array_size, samples * 8, alpha / 180 * np.pi, SNR, calib=False)
    vlen: array_size
  states: {}
- name: esprit_angle_sink
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '90'
    min: '-90'
    name: '"ESPRIT Angle"'
    type: float
  states: {}
- name: iio_ad9081_source_0
  id: iio_ad9081_source
  parameters:
    buffer_size: '32768'
    ch0_en: 'True'
    ch1_en: 'True'
    ch2_en: 'True'
    ch3_en: 'True'
    ch4_en: 'False'
    ch5_en: 'False'
    ch6_en: 'False'
    ch7_en: 'False'
    channel_freq_0: '0'
    channel_freq_1: '0'
    channel_freq_2: '0'
    channel_freq_3: '0'
    channel_freq_4: '0'
    channel_freq_5: '0'
    channel_freq_6: '0'
    channel_freq_7: '0'
    channel_phase_0: '0'
    channel_phase_1: '0'
    channel_phase_2: '0'
    channel_phase_3: '0'
    channel_phase_4: '0'
    channel_phase_5: '0'
    channel_phase_6: '0'
    channel_phase_7: '0'
    filter_file: ''
    len_tag_key: ''
    main_freq_0: '-1.55e9'
    main_freq_1: '-1.55e9'
    main_freq_2: '-1.55e9'
    main_freq_3: '-1.55e9'
    main_phase_0: '0'
    main_phase_1: '0'
    main_phase_2: '0'
    main_phase_3: '0'
    nyquist_zone: 'True'
    uri: ip:192.168.3.1
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: ofdmradar_array_calib_0
  id: ofdmradar_array_calib
  parameters:
    array_size: array_size
    pilot_angle: '0'
    targets: '1'
  states: {}
- name: ofdmradar_array_corr_0
  id: ofdmradar_array_corr
  parameters:
    array_size: array_size
    samples: samples
  states: {}
- name: ofdmradar_array_esprit_0
  id: ofdmradar_array_esprit
  parameters:
    array_size: array_size
    targets: targets
  states: {}
- name: ofdmradar_array_music_0
  id: ofdmradar_array_music
  parameters:
    array_size: array_size
    output_resolution: output_resolution
    targets: targets
  states: {}
- name: qtgui_compass_0
  id: qtgui_compass
  parameters:
    fullNeedle: '1'
    min_size: '250'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: output_resolution
    x_start: '-90'
    x_step: 180 / output_resolution
    ymax: '1.1'
    ymin: '0'
  states: {}
- name: test_waveform_gen
  id: epy_module
  parameters:
    source_code: "import numpy as np\n\nphi = None\n\ndef get_waveform(elements, N, alpha, SNR_dB, calib=True):\n    global phi\n\n    if phi is None:\n        phi = np.exp(1j * 2*np.pi * np.random.randn(elements))\n\n    if calib:\n        s = np.ones((elements, N)) # np.exp(1j * 0.1 * 2*np.pi * np.arange(elements))\n    else:\n        s = np.ones((elements, N)) * phi[:,np.newaxis]\n\n    SNR = 10 ** (SNR_dB/10)\n    N_0 = 1/SNR\n    sigma = np.sqrt(N_0/2)\n    n = sigma * (np.random.randn(elements, N) + 1j * np.random.randn(elements, N))\n\n    omega = np.sin(alpha)\n    d = np.arange(elements, dtype=float)/2\n    steer = np.exp(1j * 2*np.pi * omega * d)\n\n    x = np.tile((s * steer[:,np.newaxis]) + n, 2)\n    return np.transpose(x).reshape(np.prod(x.shape))\n\n"
  states: {}

connections:
- [array_calib_button, pressed, ofdmradar_array_calib_0, trigger]
- [blocks_multiply_const_xx_0, '0', esprit_angle_sink, '0']
- [blocks_multiply_const_xx_0, '0', qtgui_compass_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_streams_to_vector_0, '0', ofdmradar_array_corr_0, '0']
- [blocks_vector_source_x_0, '0', blocks_probe_rate_0, '0']
- [blocks_vector_source_x_0, '0', ofdmradar_array_corr_0, '0']
- [iio_ad9081_source_0, '0', blocks_streams_to_vector_0, '0']
- [iio_ad9081_source_0, '1', blocks_streams_to_vector_0, '1']
- [iio_ad9081_source_0, '2', blocks_streams_to_vector_0, '2']
- [iio_ad9081_source_0, '3', blocks_streams_to_vector_0, '3']
- [ofdmradar_array_calib_0, calib, ofdmradar_array_corr_0, calib]
- [ofdmradar_array_corr_0, '0', ofdmradar_array_calib_0, '0']
- [ofdmradar_array_corr_0, '0', ofdmradar_array_esprit_0, '0']
- [ofdmradar_array_corr_0, '0', ofdmradar_array_music_0, '0']
- [ofdmradar_array_esprit_0, '0', blocks_multiply_const_xx_0, '0']
- [ofdmradar_array_music_0, '0', qtgui_vector_sink_f_0, '0']

metadata:
  file_format: 1
