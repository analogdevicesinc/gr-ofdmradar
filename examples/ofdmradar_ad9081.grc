options:
  parameters:
    generate_options: qt_gui
    id: ofdmradar_ad9081
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amplitude
  id: variable_qtgui_range
  parameters:
    label: Test Signal Power
    start: '-100'
    step: '0.1'
    stop: '0'
    value: '-50'
  states: {}
- name: buffer_size
  id: variable
  parameters:
    value: 2**18
  states: {}
- name: display_mult
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '80'
    value: '40'
  states: {}
- name: doppler
  id: variable_qtgui_range
  parameters:
    start: '-50000'
    step: '1'
    stop: '50000'
    value: '0'
  states: {}
- name: f_c
  id: variable_qtgui_range
  parameters:
    label: Center Frequency
    start: '-7.5e9'
    step: 1e7
    stop: 7.5e9
    value: 2.45e9
  states: {}
- name: iio_target
  id: variable
  parameters:
    value: '"ip:192.168.3.1"'
  states: {}
- name: phi
  id: variable_qtgui_range
  parameters:
    label: Phase
    start: '-360'
    step: '0.1'
    stop: '360'
    value: '0'
  states: {}
- name: radar_params
  id: ofdmradar_ofdmradar_params
  parameters:
    carriers: '4096'
    constellation_order: '4'
    custom_constellation: '[1.0, -1.0]'
    cyclic_prefix_length: '256'
    dc_guard: '1'
    modulation_scheme: QPSK
    nyquist_guard: '64'
    peri_carriers: '8192'
    peri_symbols: '32'
    seed: '0'
    symbols: '16'
    wintype: HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 250e6
  states: {}
- name: t_0
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.001'
    stop: '1'
    value: '0.01795'
  states: {}
- name: awg_mod
  id: epy_module
  parameters:
    source_code: |
      import numpy as np

      def gen(f, N, f_s):
          T = N / f_s
          t = np.linspace(-T/2, T/2, N)
          return np.sinc(f*t)
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: 10**(amplitude/20)
    type: complex
  states: {}
- name: blocks_multiply_const_xx_1
  id: blocks_multiply_const_xx
  parameters:
    const: 10**(display_mult/20)
    type: complex
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {}
- name: blocks_vector_source_x_0_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: awg_mod.gen(100000000, buffer_size//8, samp_rate) * 10**(amplitude/20)
  states: {state: disabled}
- name: iio_ad9081_sink_0
  id: iio_ad9081_sink
  parameters:
    buffer_size: radar_params.frame_length
    ch0_en: 'False'
    ch1_en: 'False'
    ch2_en: 'False'
    ch3_en: 'True'
    ch4_en: 'False'
    ch5_en: 'False'
    ch6_en: 'False'
    ch7_en: 'False'
    channel_freq_0: '0'
    channel_freq_1: '0'
    channel_freq_2: '0'
    channel_freq_3: '0'
    channel_freq_4: '0'
    channel_freq_5: '0'
    channel_freq_6: '0'
    channel_freq_7: '0'
    channel_phase_0: '0'
    channel_phase_1: '0'
    channel_phase_2: '0'
    channel_phase_3: '0'
    channel_phase_4: '0'
    channel_phase_5: '0'
    channel_phase_6: '0'
    channel_phase_7: '0'
    cyclic: 'False'
    len_tag_key: packet_len
    main_freq_0: f_c+doppler
    main_freq_1: f_c+doppler
    main_freq_2: f_c+doppler
    main_freq_3: f_c+doppler
    main_phase_0: '0'
    main_phase_1: '0'
    main_phase_2: '0'
    main_phase_3: '0'
    uri: iio_target
  states: {}
- name: iio_ad9081_source_0
  id: iio_ad9081_source
  parameters:
    buffer_size: buffer_size
    ch0_en: 'True'
    ch1_en: 'False'
    ch2_en: 'False'
    ch3_en: 'False'
    ch4_en: 'False'
    ch5_en: 'False'
    ch6_en: 'False'
    ch7_en: 'False'
    channel_freq_0: '0'
    channel_freq_1: '0'
    channel_freq_2: '0'
    channel_freq_3: '0'
    channel_freq_4: '0'
    channel_freq_5: '0'
    channel_freq_6: '0'
    channel_freq_7: '0'
    channel_phase_0: '0'
    channel_phase_1: '0'
    channel_phase_2: '0'
    channel_phase_3: '0'
    channel_phase_4: '0'
    channel_phase_5: '0'
    channel_phase_6: '0'
    channel_phase_7: '0'
    filter_file: ''
    len_tag_key: packet_len
    main_freq_0: gr.nyquist_fold(f_c, 4e9)
    main_freq_1: gr.nyquist_fold(f_c, 4e9)
    main_freq_2: gr.nyquist_fold(f_c, 4e9)
    main_freq_3: gr.nyquist_fold(f_c, 4e9)
    main_phase_0: phi/180*np.pi
    main_phase_1: phi/180*np.pi
    main_phase_2: phi/180*np.pi
    main_phase_3: phi/180*np.pi
    nyquist_zone: 'False'
    uri: iio_target
  states: {}
- name: iio_tdd_control_0
  id: iio_tdd_control
  parameters:
    burst_count: '0'
    enable_rx: 'True'
    enable_secondary: 'False'
    enable_tx: 'True'
    frame_length: '30'
    gate_rx: 'True'
    gate_tx: 'True'
    primary_rx_dp_off_ms: '0.03'
    primary_rx_dp_on_ms: '0.02'
    primary_rx_rf_off_ms: '0'
    primary_rx_rf_on_ms: '0'
    primary_rx_vco_off_ms: '0'
    primary_rx_vco_on_ms: '0'
    primary_tx_dp_off_ms: t_0+0.01
    primary_tx_dp_on_ms: t_0
    primary_tx_rf_off_ms: '0'
    primary_tx_rf_on_ms: '0'
    primary_tx_vco_off_ms: '0'
    primary_tx_vco_on_ms: '0'
    secondary_rx_dp_off_ms: '0'
    secondary_rx_dp_on_ms: '0'
    secondary_rx_rf_off_ms: '0'
    secondary_rx_rf_on_ms: '0'
    secondary_rx_vco_off_ms: '0'
    secondary_rx_vco_on_ms: '0'
    secondary_tx_dp_off_ms: '0'
    secondary_tx_dp_on_ms: '0'
    secondary_tx_rf_off_ms: '0'
    secondary_tx_rf_on_ms: '0'
    secondary_tx_vco_off_ms: '0'
    secondary_tx_vco_on_ms: '0'
    terminal_type: 'True'
    uri: iio_target
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: ofdmradar_ofdmradar_gui_0
  id: ofdmradar_ofdmradar_gui
  parameters:
    ofdm_params: radar_params
  states: {}
- name: ofdmradar_ofdmradar_rx_0
  id: ofdmradar_ofdmradar_rx
  parameters:
    buffer_size: buffer_size
    len_tag_key: packet_len
    ofdm_radar_params: radar_params
  states: {}
- name: ofdmradar_ofdmradar_tx_0
  id: ofdmradar_ofdmradar_tx
  parameters:
    len_tag_key: packet_len
    ofdm_radar_params: radar_params
  states: {}
- name: ofdmrx_mod
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph

      import numpy as np
      import matplotlib
      import matplotlib.pyplot as plt

      counter = 0
      running_sum = np.zeros((1024, 64), dtype=float)

      def handle_data(data):
          global counter,running_sum
          estimate = np.fft.fftshift(data, axes=[0])
          estimate = np.transpose(estimate)

          matplotlib.use("agg")
          plt.figure(figsize=(8, 10))
          running_sum = np.abs(estimate)[::-1,:]
          plt.imshow(running_sum, interpolation="none", aspect=1/2, extent=[-32, 31, 0, 1023])
          # plt.imshow(np.transpose(np.abs(data)))
          # plt.colorbar()
          plt.ylim([0, 200])
          plt.ylabel("Distance")
          plt.xlabel("Doppler");
          ofile = f"/tmp/periodograms/{counter:03}.png"

          plt.savefig(ofile)
          plt.close()
          counter += 1
          # print(f"Wrote: {ofile}")
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
    update_time: 1/60
    xmax: '1'
    xmin: '-1'
    ymax: '1'
    ymin: '-1'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: f_c
    fftsize: '8192'
    tr_level: '-80'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: burst
    type: complex
    update_time: 1/60
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: buffer_size
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
    update_time: 1/60
  states: {state: disabled}

connections:
- [blocks_multiply_const_xx_0, '0', iio_ad9081_sink_0, '0']
- [blocks_multiply_const_xx_1, '0', ofdmradar_ofdmradar_gui_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_vector_source_x_0_1, '0', iio_ad9081_sink_0, '0']
- [iio_ad9081_source_0, '0', blocks_probe_rate_0, '0']
- [iio_ad9081_source_0, '0', ofdmradar_ofdmradar_rx_0, '0']
- [iio_ad9081_source_0, '0', qtgui_const_sink_x_0, '0']
- [iio_ad9081_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [iio_ad9081_source_0, '0', qtgui_time_sink_x_1, '0']
- [ofdmradar_ofdmradar_rx_0, '0', blocks_multiply_const_xx_1, '0']
- [ofdmradar_ofdmradar_tx_0, '0', blocks_multiply_const_xx_0, '0']

metadata:
  file_format: 1
